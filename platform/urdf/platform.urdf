Commit message: added final platform

File: platform/urdf/platform.urdf (robot description, URDF)
Before this commit: robot platform, 1 links, 0 joints
Links:
- link platform: mass 482.29 -> 437.49
