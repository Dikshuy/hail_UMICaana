Commit message: updated cannon7

File: cannon7/urdf/cannon.urdf (robot description, URDF)
Before this commit: robot cannon, 2 links, 1 joints
Links:
- link piston: geometry collision cylinder length=0.01 radius=0.005; visual mesh filename=package://cannon7/meshes/piston.STL
